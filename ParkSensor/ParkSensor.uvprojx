# Keil uVision project ParkSensor.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ParkSensor
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.s DISPLAY.s TRANSMIT.s LCD_INIT.s GPIO_INIT.s INIT_TIMER0.s TIMER0A_HANDLER.s ADC_INIT.s printdigit.s DELAY100.s CONVRT.s OutStr.s ULTRASOUND_INITS.s ULTRASOUND_MEASUREMENT.s BREAKING_MODE.s THRESHOLD_MODE.s UPDATE_THRESHOLD_BAR.s INIT_TIMER3.s MOTOR_GPIO.s TIMER3A_HANDLER.s
